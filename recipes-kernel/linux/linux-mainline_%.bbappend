FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://01-uart2-enable-licheepi-zero-dock-dts.patch \
	    file://01-mic-enable-licheepi-zero-dock-dts.patch   \	
"
